#
DESCRIPTION = "Rockchip binary tools, uses yocto-old branch"

#LICENSE = "BINARY"
#LIC_FILES_CHKSUM = "file://LICENSE.TXT;md5=564e729dd65db6f65f911ce0cd340cf9"
#LIC_FILES_CHKSUM = "file://LICENSE.TXT"
#NO_GENERIC_LICENSE[BINARY] = "LICENSE.TXT"

SRC_URI = "git://github.com/rockchip-linux/rkbin.git;branch=yocto-old"
SRCREV = "f64ded672836b47db3f6a0d04d8ccb4180fb3d55"

#SRC_URI = "git://github.com/rockchip-linux/rkbin.git"
#SRCREV = "${AUTOREV}"

