SRC_URI = " \
        https://github.com/rockchip-linux/libmali/raw/29mirror/lib/${MALI_TUNE}/${MALI_NAME} \
"
SRCREV = "${AUTOREV}"


